## linux/drivers/comento/Kconfig
```kconfig
config COMENTO_DRIVER
    bool "Comento SoC device drivers"
    help
        This enables device drivers for Comento SoC
```
